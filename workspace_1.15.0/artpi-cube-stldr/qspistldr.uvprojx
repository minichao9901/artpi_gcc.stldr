# Keil uVision project qspistldr.uvprojx, settings and files
target FlashDownLoad (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ARTPI_H750_QSPI
  AfterMake: cmd.exe /C copy "!L" ".\@L.stldr"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FLASH_MEM, USE_HAL_DRIVER, STM32H750xx
  c include: .\Drivers;.\Template;.\Library\CORE;.\Library\HALLIB\Inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ./Template/Target.sct
  link misc: --diag_suppress L6305
  group Program Functions
    ./Template/: Loader_Src.c
  group Device Description
    ./Template/: Dev_Inf.c
  group Libraries
    ./Library/HALLIB/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mdma.c
  group Drivers
    ./Drivers/: qspi.c exflash.c system_stm32h7xx.c
